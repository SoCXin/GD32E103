# Keil uVision project composite_msc_cdc.uvproj, settings and files
target USBFS_Composite_MSC_CDC (ARM-ADS)
  device: GD32E103VB GigaDevice
  cpu: IRAM(0x20000000-0x20007FFF)IROM(0x08000000-0x0801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32E10X GD32E103V_EVAL
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Utilities;..\..\..\..\..\Firmware\CMSIS\GD\GD32E10x\Include;..\..\..\..\..\Firmware\GD32E10x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32E10x_usbfs_driver\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../src/: app.c usb_delay.c cdc_acm_core.c gd32e10x_it.c msc_cdc_wrapper.c usbd_bbb_scsi.c usbd_flash_access.c usbd_msc_core.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group GD32E10x_EVAL
    ../../../../../Utilities/: gd32e10x_eval.c
  group GD32E10x_StdPeriph_Driver
    ../../../../../Firmware/GD32E10x_standard_peripheral/Source/: gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_timer.c gd32e10x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group USB_Driver
    ../../../../../Firmware/GD32E10x_usbfs_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group Doc
    ../: readme.txt
