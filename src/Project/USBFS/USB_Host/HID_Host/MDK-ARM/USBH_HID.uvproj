# Keil uVision project USBH_HID.uvproj, settings and files
target USBH_HID (ARM-ADS)
  device: GD32E103VB GigaDevice
  cpu: IRAM(0x20000000-0x20007FFF)IROM(0x08000000-0x0801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32E10X GD32E103V_EVAL
  c include: ..\inc;..\..\..\..\..\Utilities;..\..\..\..\..\Utilities\LCD_Commom;..\..\..\..\..\Firmware\CMSIS\GD\GD32E10x\Include;..\..\..\..\..\Firmware\GD32E10x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32E10x_usbfs_driver\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../src/: main.c usbh_usr.c usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usb_delay.c gd32e10x_it.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group GD32E10x_Peripherals
    ../../../../../Firmware/GD32E10x_standard_peripheral/Source/: gd32e10x_dbg.c gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_timer.c gd32e10x_usart.c
  group GD32E10x_EVAL
    ../../../../../Utilities/: gd32e10x_eval.c gd32e10x_lcd_eval.c
    ../../../../../Utilities/LCD_Commom/: lcd_log.c lcd_font.c
  group USB_Driver
    ../../../../../Firmware/GD32E10x_usbfs_driver/Source/: usb_core.c usbh_core.c usbh_ctrl.c usbh_hcs.c usbh_int.c usbh_std.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group Doc
    ../: readme.txt
